# Keil uVision project 400G_SR4_OSFP.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: GD32E512ME GigaDevice
  pack: GigaDevice.GD32E511_512_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: 400G_SR4_OSFP +hex
  AfterMake: cmd /c C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ..\..\bin\app_tmp .\Objects\400G_SR4_OSFP.axf && move /Y ..\..\bin\app_tmp\ER_IROM1 ..\..\bin\400G_SR4_OSFP.bin && rmdir /S /Q ..\..\bin\app_tmp && C:\Users\86177\.tools\py313\python.exe C:\Users\86177\Desktop\project\400G_SR4_OSFP\tools\pack_framed_bin.py || echo *** AFTERMAKE-FAILED: fromelf or pack failed; check bin\app_tmp / bin\400G_SR4_OSFP.bin / bin\400G_SR4_OSFP_framed.bin ***
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32E511_512
  c include: ..\..\driver\projectfiles\inc;..\..\common;..\..\driver\mcu\core;..\..\driver\mcu\peripheral\include;..\..\driver\mcu\system;..\..\resource;..\..\resource_impl;..\..\driver\odsp\projectfiles\inc;..\..\driver\odsp\projectfiles;..\..\driver\odsp\adapt;..\..\driver\mcu\adpat\inc;..\..\driver\drv\inc;..\..\driver\tia\inc;..\..\driver\pmic\inc;..\..\driver\extflash\inc;..\..\protocol\mci\inc;..\..\protocol\ral\inc;..\..\protocol\adpat\inc;..\..\protocol\mal\inc;..\..\protocol\msl\inc;..\..\protocol\cdb\inc
  memory RVCT4: ROM 0x8010200 size 0x2de00
  memory RVCT9: RAM 0x2000d500 size 0x12b00
  group common
    ../../common/: basedef.h
  group main
    ../../main/: main.c
  group protocols
    ../../protocol/ral/src/: ral.c ral_operate.c
    ../../protocol/mci/src/: data_transfer.c i2c_slave.c
    ../../protocol/adpat/src/: adpat.c
    ../../protocol/mal/src/: dpsm.c monitor.c monitor_impl.c msm.c mgmt_init.c msm_pwr_seq.c vdm.c
    ../../protocol/cdb/src/: cdb.c
    ../../protocol/msl/src/: msl.c
  group resource
    ../../resource/: adcresource.c chipresource.c dacresource.c gpioresource.c busresource.c boardresource.c flashresource.c sramresource.c
  group resourceimpl
    ../../resource_impl/: adcresource_impl.c chipresource_impl.c dacresource_impl.c gpioresource_impl.c busresource_impl.c boardresource_impl.c flashresource_impl.c sramresource_impl.c memory_map.h
  group startup
    ../../driver/mcu/startup/: startup_gd32e511_512.s
  group mcu
    ../../driver/mcu/peripheral/src/: gd32e511_512_adc.c gd32e511_512_cla.c gd32e511_512_cmp.c gd32e511_512_crc.c gd32e511_512_dac.c gd32e511_512_dbg.c gd32e511_512_dma.c gd32e511_512_exti.c gd32e511_512_fmc.c gd32e511_512_fwdgt.c gd32e511_512_gpio.c gd32e511_512_i2c.c gd32e511_512_i3c.c gd32e511_512_mdio.c gd32e511_512_misc.c gd32e511_512_opa.c gd32e511_512_pmu.c gd32e511_512_rcu.c gd32e511_512_rtc.c gd32e511_512_spi.c gd32e511_512_syscfg.c gd32e511_512_timer.c gd32e511_512_usart.c gd32e511_512_wwdgt.c
  group odsp
    ../../driver/odsp/projectfiles/src/: capi.c capi_diag.c capi_test.c host_chip_wrapper.c host_diag.c host_download_util.c host_test.c host_to_chip_ipc.c
    ../../driver/projectfiles/src/: reg_access_arm.c hr_time_arm.c
  group projectfiles
    ../../driver/projectfiles/src/: ml_cw_rtmr_handler.c ml_cw_rtmr_modes.c ml_cw_xbar.c chal_cw_rtmr_clkrst_control.c chal_cw_rtmr_clockrst_mux.c chal_cw_rtmr_datapath_cfg.c chal_cw_rtmr_kp4prbs.c chal_cw_rtmr_status_check.c chal_cw_top.c chal_gpio.c chal_lw_diag_info_p.c hw_mutex_handler.c dsp_config.c logger.c tunnel_access.c common_util.c chip_config.c dsp_utils.c host_chip_mem_map.c host_avs.c host_diag_fec_statistics.c host_diag_lw_p.c host_diag_util.c host_fec_prbs.c host_gpio_util.c host_lw_wrapper.c host_power_util.c chal_cw_prbs.c chal_cw_rtmr_xdec.c chal_cw_rtmr_xenc.c chal_cw_utils.c bcm_arm_platform.c gd32_error_report.c bcm_gd32_i2c.c bcm_bsc.c
    ../../driver/mcu/system/: system_gd32e511_512.c
  group adapt
    ../../driver/mcu/adpat/src/: mcu_clock.c timer2_scheduler.c mcu_i2c.c mcu_spi.c watchdog.c
  group odsp_adapt
    ../../driver/odsp/adapt/: odsp_adapt.c odsp_init.c odsp_lp_mode.c odsp_los_mon.c odsp_lasi.c odsp_opt_mon.c odsp_serdes_profile.c odsp_telemetry.c
  group drv
    ../../driver/drv/src/: drv.c
  group tia
    ../../driver/tia/src/: tia.c
  group pmic
    ../../driver/pmic/src/: pmic.c
  group extflash
    ../../driver/extflash/src/: extflash.c
