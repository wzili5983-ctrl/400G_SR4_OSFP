# Keil uVision project 400G_SR4_OSFP_BL.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: GD32E512ME GigaDevice
  pack: GigaDevice.GD32E511_512_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: 400G_SR4_OSFP_BL +hex
  AfterMake: cmd /c C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ..\..\bin\bl_tmp .\Objects\400G_SR4_OSFP_BL.axf && move /Y ..\..\bin\bl_tmp\ER_IROM1 ..\..\bin\400G_SR4_OSFP_BL.bin && rmdir /S /Q ..\..\bin\bl_tmp || echo *** AFTERMAKE-FAILED: BL bin possibly not refreshed; check bin\bl_tmp ***
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32E511_512,VECT_TAB_OFFSET=0,BL_BUILD
  c include: ..\..\driver\projectfiles\inc;..\..\common;..\..\driver\mcu\core;..\..\driver\mcu\peripheral\include;..\..\driver\mcu\system;..\..\resource;..\..\resource_impl;..\..\driver\odsp\projectfiles\inc;..\..\driver\odsp\projectfiles;..\..\driver\mcu\adpat\inc;..\..\driver\drv\inc;..\..\driver\tia\inc;..\..\driver\pmic\inc;..\..\protocol\mci\inc;..\..\protocol\ral\inc;..\..\protocol\adpat\inc;..\..\protocol\mal\inc;..\..\protocol\msl\inc;..\..\protocol\cdb\inc;..\bootloader\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x2000d500 size 0x12b00
  group common
    ../../common/: basedef.h
  group main
    ../bootloader/src/: main.c
  group bootloader
    ../bootloader/src/: bl_promote.c bl_ral_tab.c bl_ral_operate.c
  group protocols
    ../../protocol/mci/src/: data_transfer.c i2c_slave.c
    ../../protocol/adpat/src/: adpat.c
    ../../protocol/cdb/src/: cdb.c
  group resource
    ../../resource/: flashresource.c sramresource.c
  group resourceimpl
    ../../resource_impl/: flashresource_impl.c sramresource_impl.c memory_map.h
  group startup
    ../../driver/mcu/startup/: startup_gd32e511_512.s
  group mcu
    ../../driver/mcu/peripheral/src/: gd32e511_512_adc.c gd32e511_512_cla.c gd32e511_512_cmp.c gd32e511_512_crc.c gd32e511_512_dac.c gd32e511_512_dbg.c gd32e511_512_dma.c gd32e511_512_exti.c gd32e511_512_fmc.c gd32e511_512_fwdgt.c gd32e511_512_gpio.c gd32e511_512_i2c.c gd32e511_512_i3c.c gd32e511_512_mdio.c gd32e511_512_misc.c gd32e511_512_opa.c gd32e511_512_pmu.c gd32e511_512_rcu.c gd32e511_512_rtc.c gd32e511_512_spi.c gd32e511_512_syscfg.c gd32e511_512_timer.c gd32e511_512_usart.c gd32e511_512_wwdgt.c
  group system
    ../../driver/mcu/system/: system_gd32e511_512.c
  group adapt
    ../../driver/mcu/adpat/src/: mcu_clock.c timer2_scheduler.c watchdog.c
